# Keil uVision project Usb_VirtualCom.uvproj, settings and files
target FLASH_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Usb_VirtualCom +hex
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Drivers\include;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group CMSIS-CM3-CM4
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc_adc.c lpc_clkpwr.c lpc_exti.c lpc_gpdma.c lpc_gpio.c lpc_pinsel.c lpc_uart.c lpc_timer.c lpc_ssp.c
  group Main
    ../: cdcuser.c serial.c usbcore.c usbdesc.c usbhw.c usbuser.c vcomdemo.c
  group Readme
    ../: abstract.txt
target RAM_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Usb_VirtualCom
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Usb_VirtualCom +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target RAM_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: Usb_VirtualCom +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__, CORE_M4
  c include: ..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
