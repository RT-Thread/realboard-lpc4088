# IAR project PolarSSL.ewp, settings and files
configuration Flash_M3 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DNS_USED
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe068, Pe550, Pe186, Pa039, Pe144, Pe128, Pe177
  ICCARM.CCIncludePath2: ..\apps\webclient; ..\apps\resolv; ..\apps\dhcpc; ..\lpc_port; ..\uIP; ..\polarssl\include; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_M4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: DNS_USED; CORE_M4
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Common
    ../../../../BoardSupport/: phylan.c
    ../common/: printf-stdarg.c Serial.c
  group DHCP
    ../apps/dhcpc/: dhcpc.c
  group DNS
    ../apps/resolv/: resolv.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc_clkpwr.c lpc_emac.c lpc_emc.c lpc_pinsel.c lpc_timer.c lpc_uart.c
    ../../../../BoardSupport/: sdram_is42s32800d.c sdram_k4s561632j.c sdram_mt48lc8m32lfb5.c
  group PolarSSL
    ../polarssl/library/: aes.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c error.c gcm.c md.c md2.c md4.c md5.c md_wrap.c padlock.c pbkdf2.c pem.c pkcs11.c rsa.c sha1.c sha2.c sha4.c ssl_cache.c ssl_cli.c ssl_tls.c version.c x509parse.c x509write.c xtea.c
  group Port
    ../lpc_port/: clock-arch.c emac.c Emac_uIP.c
  group Readme
    ../: abstract.txt
  group SslClient
    ../lpc_port/: ssl_client1.c
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/IAR/: startup_LPC407x_8x_177x_8x.s
  group uIP
    ../uip/: psock.c timer.c uip.c uip_arp.c uiplib.c
  group WebClient
    ../apps/webclient/: webclient-strings.c webclient.c
