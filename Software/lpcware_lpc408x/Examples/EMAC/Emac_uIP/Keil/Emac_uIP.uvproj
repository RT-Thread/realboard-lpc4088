# Keil uVision project Emac_uIP.uvproj, settings and files
target FLASH_M3_WebServer (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: WEB_SERVER
  c include: ..\apps\webserver;..\lpc_port;..\uip;..\apps;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Core Files
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group Driver Files
    ../../../../Drivers/source/: debug_frmwrk.c lpc_uart.c lpc_clkpwr.c lpc_emac.c lpc_pinsel.c lpc_gpio.c
    ../../../../BoardSupport/: phylan.c
  group port
    ../lpc_port/: clock-arch.c emac.c Emac_uIP.c
  group Common
    ../common/: Serial.c
  group uIP
    ../uip/: uip_arp.c psock.c timer.c uip.c uiplib.c
  group DHCP
    ../apps/dhcpc/: dhcpc.c
  group DNS
    ../apps/resolv/: resolv.c
  group Webserver
    ../apps/webserver/: httpd-cgi.c httpd-fs.c http-strings.c httpd.c
  group WebClient
    ../apps/webclient/: webclient.c webclient-strings.c
    ../apps/webbrowser/: htmlparser.c html-strings.c
  group SMTP
    ../lib/: base64.c
    ../apps/smtp/: smtp.c smtp-strings.c
  group Telnet
    ../lib/: memb.c
    ../apps/telnetd/: shell.c telnetd.c
  group Readme
    ../: abstract.txt
target FLASH_M4_WebServer (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4, WEB_SERVER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M3_WebClient (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: WEB_CLIENT,WEB_BROWSER,DNS_USED,DHCP_ENABLE
  c include: ..\apps\webclient;..\lpc_port;..\uip;..\apps;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\apps\dhcpc;..\apps\resolv;..\apps\webbrowser
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M4_WebClient (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4, WEB_CLIENT,WEB_BROWSER,DNS_USED,DHCP_ENABLE
  c include: ..\apps\webclient;..\lpc_port;..\uip;..\apps;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\apps\webbrowser;..\apps\dhcpc;..\apps\resolv
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M3_SMTP (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: SMTP_APP,DNS_USED,DHCP_ENABLE
  c include: ..\apps\smtp;..\apps\resolv;..\apps\dhcpc;..\lib;..\lpc_port;..\uip;..\apps;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M4_SMTP (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4,SMTP_APP,DNS_USED,DHCP_ENABLE
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M3_Telnet (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: TELNET_APP
  c include: ..\apps\telnetd;..\lib;..\lpc_port;..\uip;..\apps;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M4_Telnet (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: Emac_uIP +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4,TELNET_APP
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
