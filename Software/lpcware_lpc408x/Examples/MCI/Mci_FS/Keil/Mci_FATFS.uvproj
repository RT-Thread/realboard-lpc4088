# Keil uVision project Mci_FATFS.uvproj, settings and files
target FLASH_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Mci_FATFs +hex
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\FatFs;..\..\Mci_FS;..\main
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group CMSIS-CM3-CM4
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Drivers
    ../../../../Drivers/source/: lpc_pinsel.c lpc_clkpwr.c lpc_mci.c lpc_gpdma.c debug_frmwrk.c lpc_uart.c lpc_rtc.c
  group Main
    ../main/: fs_mci.c monitor.c fatfs_main.c
  group Readme
    ../: fatfs_abstract.txt
  group FATFs
    ../FatFs/: ff.c
    ../FatFs/option/: ccsbcs.c
target FLASH_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Mci_FATFs +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
