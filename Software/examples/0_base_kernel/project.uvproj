# Keil uVision project project.uvproj, settings and files
target rt-thread_lpc40xx (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-lpc40xx +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: CORE_M4
  c include: .;..\..\..\..\..\..\RTT_Git\rt-thread-2013-12-17\components\drivers\include;..\..\..\..\..\..\RTT_Git\rt-thread-2013-12-17\include;..\..\..\..\..\..\RTT_Git\rt-thread-2013-12-17\libcpu\arm\common;..\..\..\..\..\..\RTT_Git\rt-thread-2013-12-17\libcpu\arm\cortex-m4;..\..\drivers;..\..\libraries\CMSIS\Include;..\..\libraries\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\libraries\Drivers\include;applications
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Libraries
    ../../libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ../../libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
    ../../libraries/Drivers/source/: lpc_adc.c lpc_bod.c lpc_can.c lpc_clkpwr.c lpc_crc.c lpc_dac.c lpc_eeprom.c lpc_emc.c lpc_exti.c lpc_gpdma.c lpc_gpio.c lpc_i2c.c lpc_i2s.c lpc_iap.c lpc_lcd.c lpc_mcpwm.c lpc_nvic.c lpc_pinsel.c lpc_pwm.c lpc_qei.c lpc_rtc.c lpc_ssp.c lpc_systick.c lpc_timer.c lpc_uart.c lpc_wwdt.c
  group Drivers
    ../../drivers/: board.c drv_i2c.c drv_key.c drv_lcd.c drv_led.c drv_rtc.c drv_sd.c drv_sdram.c drv_spi.c drv_sram.c drv_touch.c drv_uart.c
  group Applications
    applications/: application.c startup.c
  group Kernel
    ../../../../../../RTT_Git/rt-thread-2013-12-17/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../../../../RTT_Git/rt-thread-2013-12-17/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../../../RTT_Git/rt-thread-2013-12-17/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../../../../RTT_Git/rt-thread-2013-12-17/components/drivers/serial/: serial.c
    ../../../../../../RTT_Git/rt-thread-2013-12-17/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
