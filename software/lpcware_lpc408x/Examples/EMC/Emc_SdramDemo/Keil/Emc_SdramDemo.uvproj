# Keil uVision project Emc_SdramDemo.uvproj, settings and files
target FLASH_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Emc_SdramDemo +hex
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group CMSIS-CM3-CM4
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Drivers
    ../../../../Drivers/source/: lpc_pinsel.c debug_frmwrk.c lpc_uart.c lpc_clkpwr.c lpc_crc.c lpc_emc.c lpc_timer.c
    ../../../../BoardSupport/: sdram_mt48lc8m32lfb5.c sdram_k4s561632j.c sdram_is42s32800d.c
  group Main
    ../: Emc_SdramDemo.c
  group Readme
    ../: abstract.txt
target RAM_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: Emc_SdramDemo +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__
  c include: as above
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Emc_SdramDemo +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target RAM_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: Emc_SdramDemo +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__, CORE_M4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
