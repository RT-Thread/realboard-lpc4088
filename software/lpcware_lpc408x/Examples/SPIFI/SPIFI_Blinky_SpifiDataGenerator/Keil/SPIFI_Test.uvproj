# Keil uVision project SPIFI_Test.uvproj, settings and files
target FLASH_M3 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Gpio_LedBlinky +hex
  c flags: Optim=1 wLevel=2
  c define: USE_SPIFI_LIB CORE_M4
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group CMSIS-CM3-CM4
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc_gpio.c lpc_systick.c lpc_clkpwr.c lpc_uart.c lpc_pinsel.c
  group Main
    ../: Spifi_Test.c spifi_blinky.c spifi_delay.c
    ../../../../Drivers/lib/: spifi_drv_M4.lib
  group Readme
    ../: abstract.txt
target RAM_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Gpio_LedBlinky +hex
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__
  c include: ..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
target FLASH M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: Gpio_LedBlinky +hex
  c flags: Optim=1 wLevel=2
  c define: USE_SPIFI_LIB CORE_M4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Flash_M3\spifi_blinky.sct
