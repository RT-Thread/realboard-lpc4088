# Keil uVision project cmp.uvproj, settings and files
target FLASH M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: cmptest +hex
  c flags: Optim=1
  c define: CORE_M4
  c include: ..\..\Core\CMSIS\Include;..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\Drivers\include;..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Code
    ../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group System Code
    ../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Source Code
    ./: cmp.c cmptest.c
  group Readme
    ./: abstract.txt
target RAM M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: as above
  output: cmptest +hex
  c flags: Optim=1
  c define: __RAM_MODE__,CORE_M4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
