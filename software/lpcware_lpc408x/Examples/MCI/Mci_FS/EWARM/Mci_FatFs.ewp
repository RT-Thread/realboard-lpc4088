# IAR project Mci_FatFs.ewp, settings and files
configuration Flash_M3 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161, Pe068, Pe550, Pe177, Pe223
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport; ..\main; ..\fatfs
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adc_Dma.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_M4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\linker\LPC4088_rom.icf
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc_clkpwr.c lpc_gpdma.c lpc_mci.c lpc_pinsel.c lpc_rtc.c lpc_uart.c
  group FatFS
    ../FatFs/option/: ccsbcs.c
    ../FatFs/: ff.c
  group Main
    ../main/: fatfs_main.c fs_mci.c monitor.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/IAR/: startup_LPC407x_8x_177x_8x.s
