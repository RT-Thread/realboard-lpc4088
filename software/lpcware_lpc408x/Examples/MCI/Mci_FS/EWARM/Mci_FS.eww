<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Mci_EFSL.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Mci_FatFs.ewp</path>
  </project>
  <batchBuild/>
</workspace>


