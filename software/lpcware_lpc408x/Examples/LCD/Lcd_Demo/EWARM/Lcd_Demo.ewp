# IAR project Lcd_Demo.ewp, settings and files
configuration Flash_M3 (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe068, Pe550, Pe186, Pa039, Pe144, Pe128, Pe177
  ICCARM.CCIncludePath2: ..\app; ..\modules; ..\board; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lcd_GFT035A320240Y.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_M4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\linker\LPC4088_rom.icf
  group app
    ../app/: Cursor.c main.c NXP_logo_16.c NXP_logo_2.c NXP_logo_24.c
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Drivers
    ../../../../BoardSupport/: lcd_qvga_tft.c lcd_qvga_tft_revPB1.c sdram_is42s32800d.c sdram_k4s561632j.c sdram_mt48lc8m32lfb5.c sensor_mma7455.c sensor_smb380.c tsc2046.c
    ../../../../Drivers/source/: lpc_adc.c lpc_clkpwr.c lpc_emc.c lpc_gpio.c lpc_i2c.c lpc_lcd.c lpc_pinsel.c lpc_pwm.c lpc_ssp.c lpc_timer.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/IAR/: startup_LPC407x_8x_177x_8x.s
