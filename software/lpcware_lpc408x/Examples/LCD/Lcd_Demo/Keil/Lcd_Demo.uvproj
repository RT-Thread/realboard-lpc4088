# Keil uVision project Lcd_Demo.uvproj, settings and files
target FLASH_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Lcd_Demo +hex
  c flags: Optim=1 wLevel=2
  c include: ..\board;..\app;..\config;..\modules;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group CMSIS-CM3-CM4
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Main
    ../app/: main.c
  group Readme
    ../: abstract.txt
  group App
    ../app/: Cursor.c NXP_logo_24.c NXP_logo_16.c NXP_logo_2.c
  group Drivers
    ../../../../Drivers/source/: lpc_clkpwr.c lpc_i2c.c lpc_gpio.c lpc_pinsel.c lpc_lcd.c lpc_pwm.c lpc_adc.c lpc_emc.c lpc_timer.c
    ../../../../BoardSupport/: sdram_k4s561632j.c sensor_smb380.c sdram_is42s32800d.c sdram_mt48lc8m32lfb5.c lcd_qvga_tft.c sensor_mma7455.c tsc2046.c lcd_qvga_tft_revPB1.c sdram_h57v2562gtr.c
    ../../../../Drivers/Source/: lpc_ssp.c
target FLASH_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Lcd_Demo +hex
  c flags: Optim=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
