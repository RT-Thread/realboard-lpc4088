<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Cortex_Privilege_mode.ewp</path>
  </project>
  <batchBuild/>
</workspace>


