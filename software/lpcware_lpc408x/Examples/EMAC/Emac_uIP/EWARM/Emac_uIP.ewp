# IAR project Emac_uIP.ewp, settings and files
configuration Flash_M3_WebServer (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: WEB_SERVER
  ICCARM.CCDiagSuppress: Pa039, Pa050, Pa082, Pe111, Pe188, Pe068, Pe550, Pe186, Pa039, Pe144, Pe128, Pe177
  ICCARM.CCIncludePath2: ..\apps\webserver; ..\lpc_port; ..\uIP; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash_M3_WebClient (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: WEB_CLIENT; WEB_BROWSER; DNS_USED; DHCP_ENABLE
  ICCARM.CCIncludePath2: ..\apps\webclient; ..\apps\webbrowser; ..\apps\resolv; ..\apps\dhcpc; ..\lpc_port; ..\uIP; ..\lib; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
configuration Flash_M3_SMTP (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SMTP_APP; DNS_USED; DHCP_ENABLE
  ICCARM.CCIncludePath2: ..\apps\smtp; ..\apps\resolv; ..\apps\dhcpc; ..\lpc_port; ..\uIP; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
configuration Flash_M3_Telnet (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TELNET_APP
  ICCARM.CCIncludePath2: ..\apps\telnetd; ..\lpc_port; ..\uIP; ..\lib; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
configuration Flash_M4_WebServer (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4; WEB_SERVER
  ICCARM.CCDiagSuppress: Pa039, Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  OBJCOPY.OOCOutputFile: Emac_uIP.hex
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\linker\LPC4088_rom.icf
configuration Flash_M4_WebClient (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4; WEB_CLIENT; WEB_BROWSER; DNS_USED; DHCP_ENABLE
  ICCARM.CCDiagSuppress: Pa039, Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..\apps\webclient; ..\apps\webbrowser; ..\apps\resolv; ..\apps\dhcpc; ..\lpc_port; ..\uIP; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  OBJCOPY.OOCOutputFile: Emac_uIP.hex
  ILINK.IlinkIcfFile: as above
configuration Flash_M4_SMTP (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4; SMTP_APP; DNS_USED; DHCP_ENABLE
  ICCARM.CCDiagSuppress: Pa039, Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..\apps\smtp; ..\apps\resolv; ..\apps\dhcpc; ..\lpc_port; ..\uIP; ..\lib; ..; ..\..\..\..\Core\CMSIS\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Source\Templates\IAR; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  OBJCOPY.OOCOutputFile: Emac_uIP.hex
  ILINK.IlinkIcfFile: as above
configuration Flash_M4_Telnet (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  ICCARM.CCDefines: CORE_M4; TELNET_APP
  ICCARM.CCDiagSuppress: Pa039, Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Emac_uIP.hex
  ILINK.IlinkIcfFile: as above
  group CMSIS-CM3
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
  group Common
    ../../../../BoardSupport/: phylan.c
    ../common/: printf-stdarg.c Serial.c
  group DHCP
    ../apps/dhcpc/: dhcpc.c
  group DNS
    ../apps/resolv/: resolv.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc_clkpwr.c lpc_emac.c lpc_pinsel.c lpc_uart.c
  group Port
    ../lpc_port/: clock-arch.c emac.c Emac_uIP.c
  group Readme
    ../: abstract.txt
  group SMTP
    ../lib/: base64.c
    ../apps/smtp/: smtp-strings.c smtp.c
  group Startup
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/IAR/: startup_LPC407x_8x_177x_8x.s
  group Telnet
    ../lib/: memb.c
    ../apps/telnetd/: shell.c telnetd.c
  group uIP
    ../uip/: psock.c timer.c uip.c uip_arp.c uiplib.c
  group WebClient
    ../apps/webbrowser/: html-strings.c htmlparser.c
    ../apps/webclient/: webclient-strings.c webclient.c
  group WebServer
    ../apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
