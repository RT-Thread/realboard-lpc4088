# Keil uVision project Emac_InternetRadio.uvproj, settings and files
target Flash_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Emac_WebRadio +hex
  c flags: Optim=1 wLevel=2
  c define: DNS_USED,
  c include: ..\apps\webclient;..\lpc_port;..\uip;..\apps;..\apps\resolv;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\apps\dhcpc;..\lib\mp3codec;..\lib\mp3codec\pub
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Core Files
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
  group Driver Files
    ../../../../Drivers/source/: debug_frmwrk.c lpc_uart.c lpc_clkpwr.c lpc_emac.c lpc_pinsel.c lpc_gpio.c lpc_i2c.c lpc_i2s.c lpc_gpdma.c lpc_emc.c lpc_timer.c
    ../../../../BoardSupport/: phylan.c uda1380.c sdram_is42s32800d.c sdram_k4s561632j.c sdram_mt48lc8m32lfb5.c sdram_h57v2562gtr.c
  group port
    ../lpc_port/: clock-arch.c emac.c Emac_uIP.c decoder.c
  group Common
    ../common/: Serial.c
  group uIP
    ../uip/: uiplib.c uip_arp.c psock.c timer.c uip.c
  group mp3
    ../lpc_port/asm/ARM/: asmmisc.s asmpoly.s
    ../lib/mp3codec/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
  group DHCP
    ../apps/dhcpc/: dhcpc.c
  group DNS
    ../apps/resolv/: resolv.c
  group WebClient
    ../apps/webclient/: webclient.c webclient-strings.c
  group Readme
    ../: abstract.txt
target Flash_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Emac_WebRadio +hex
  c flags: Optim=4 wLevel=2
  c define: DNS_USED,CORE_M4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group left out of the first target's files
    ../../../../BoardSupport/: sdram_h57v2562gtr.c
