# Keil uVision project PolarSSL.uvproj, settings and files
target Flash_M3 (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Emac_PolarSSL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DNS_USED
  c include: ..\lpc_port;..\uip;..\apps;..\apps\resolv;..\common;..\..\..\..\Drivers\include;..\..\..\..\BoardSupport;..\..\..\..\Core\CMSIS\Include;..\..\..\..\Core\Device\NXP\LPC407x_8x_177x_8x\Include;..\apps\dhcpc;..\polarssl\include;..\apps\webclient
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20004000 size 0x4000
  scatter file: .\Emac_PolarSSL.sct
  group Core Files
    ../../../../Core/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ./: startup_LPC407x_8x_177x_8x.s
  group Driver Files
    ../../../../Drivers/source/: debug_frmwrk.c lpc_uart.c lpc_clkpwr.c lpc_emac.c lpc_pinsel.c lpc_gpio.c lpc_rtc.c lpc_emc.c lpc_timer.c
    ../../../../BoardSupport/: phylan.c sdram_is42s32800d.c sdram_k4s561632j.c sdram_mt48lc8m32lfb5.c sdram_h57v2562gtr.c
  group port
    ../lpc_port/: clock-arch.c emac.c Emac_uIP.c
  group Common
    ../common/: Serial.c
  group polarssl
    ../polarssl/library/: aes.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c error.c gcm.c md.c md_wrap.c md2.c md4.c md5.c padlock.c pbkdf2.c pem.c pkcs11.c rsa.c sha1.c sha2.c sha4.c ssl_cache.c ssl_cli.c ssl_tls.c version.c x509parse.c x509write.c xtea.c
  group uIP
    ../uip/: uiplib.c uip_arp.c psock.c timer.c uip.c
  group DHCP
    ../apps/dhcpc/: dhcpc.c
  group DNS
    ../apps/resolv/: resolv.c
  group WebClient
    ../apps/webclient/: webclient-strings.c webclient.c
  group SSLClient
    ../lpc_port/: ssl_client1.c
  group Readme
    ../: abstract.txt
target Flash_M4 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Emac_PolarSSL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DNS_USED,CORE_M4
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Emac_PolarSSL.sct
