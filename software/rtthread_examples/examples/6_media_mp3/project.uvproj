# Keil uVision project project.uvproj, settings and files
target rt-thread_lpc40xx (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-lpc40xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: CORE_M4
  c include: .;..\..\drivers;..\..\libraries\CMSIS\Include;..\..\libraries\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\libraries\Drivers\include;E:/rt-thread/components/dfs;E:/rt-thread/components/dfs/filesystems/devfs;E:/rt-thread/components/dfs/include;E:/rt-thread/components/drivers/include;E:/rt-thread/components/finsh;E:/rt-thread/components/init;E:/rt-thread/components/pthreads;E:/rt-thread/include;E:/rt-thread/libcpu/arm/common;E:/rt-thread/libcpu/arm/cortex-m4;applications;.\mp3\pub
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Libraries
    ../../libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ../../libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
    ../../libraries/Drivers/source/: lpc_adc.c lpc_bod.c lpc_can.c lpc_clkpwr.c lpc_crc.c lpc_dac.c lpc_eeprom.c lpc_emc.c lpc_exti.c lpc_gpdma.c lpc_gpio.c lpc_i2c.c lpc_i2s.c lpc_iap.c lpc_lcd.c lpc_mcpwm.c lpc_nvic.c lpc_pinsel.c lpc_pwm.c lpc_qei.c lpc_rtc.c lpc_ssp.c lpc_systick.c lpc_timer.c lpc_uart.c lpc_wwdt.c
  group Drivers
    ../../drivers/: board.c drv_uart.c drv_sram.c drv_sdram.c drv_led.c drv_mpu.c drv_sd.c drv_i2c.c drv_uda1380.c
  group Applications
    applications/: application.c startup.c wav.c
    ./applications/: mp3.c netbuffer.c
  group Kernel
    E:/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    E:/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    E:/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    E:/rt-thread/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    E:/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    E:/rt-thread/components/dfs/filesystems/devfs/: devfs.c console.c
  group DeviceDrivers
    E:/rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    E:/rt-thread/components/drivers/serial/: serial.c
    E:/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    E:/rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    E:/rt-thread/components/init/: components.c
  group pthreads
    E:/rt-thread/components/pthreads/: clock_time.c mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
  group mp3
    ./mp3/: mp3dec.c mp3tabs.c
    ./mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ./mp3/real/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
