# Keil uVision project Blinky.uvproj, settings and files
target RTX_Blinky (ARM-ADS)
  device: LPC4088 NXP
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1
  c define: CORE_M4 __CORTEX_M4F __CMSIS_RTOS
  c include: .\applications;.\drivers;.\RTE;.\RTE\CMSIS;.\RTE\Device\LPC4088FET208;.\RTE\CMSIS_RTX\INC;.\RTE\CMSIS_RTX\SRC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group applications
    ./applications/: main.c
  group drivers
    ./drivers/: drv_led.c
  group CMSIS
    ./RTE/CMSIS/: RTX_Conf_CM.c
    ./RTE/CMSIS_RTX/INC/: cmsis_os.h RTX_CM_lib.h
    ./RTE/CMSIS_RTX/LIB/ARM/: RTX_CM4.lib
  group Device
    ./RTE/Device/LPC4088FET208/: system_LPC407x_8x_177x_8x.c startup_LPC407x_8x_177x_8x.s
